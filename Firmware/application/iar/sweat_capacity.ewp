# IAR project sweat_capacity.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_CUSTOM; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_DFU_SVCI_ENABLED; NRF_DFU_TRANSPORT_BLE=1; NRF_SD_BLE_API_VERSION=6; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0; BSP_SIMPLE
  ICCARM.CCIncludePath2: ..\config; ..\source; $NRF_SDK_DIR$\components; $NRF_SDK_DIR$\components\ble\ble_advertising; $NRF_SDK_DIR$\components\ble\ble_dtm; $NRF_SDK_DIR$\components\ble\ble_link_ctx_manager; $NRF_SDK_DIR$\components\ble\ble_racp; $NRF_SDK_DIR$\components\ble\ble_services\ble_ancs_c; $NRF_SDK_DIR$\components\ble\ble_services\ble_ans_c; $NRF_SDK_DIR$\components\ble\ble_services\ble_bas; $NRF_SDK_DIR$\components\ble\ble_services\ble_bas_c; $NRF_SDK_DIR$\components\ble\ble_services\ble_cscs; $NRF_SDK_DIR$\components\ble\ble_services\ble_cts_c; $NRF_SDK_DIR$\components\ble\ble_services\ble_dfu; $NRF_SDK_DIR$\components\ble\ble_services\ble_dis; $NRF_SDK_DIR$\components\ble\ble_services\ble_gls; $NRF_SDK_DIR$\components\ble\ble_services\ble_hids; $NRF_SDK_DIR$\components\ble\ble_services\ble_hrs; $NRF_SDK_DIR$\components\ble\ble_services\ble_hrs_c; $NRF_SDK_DIR$\components\ble\ble_services\ble_hts; $NRF_SDK_DIR$\components\ble\ble_services\ble_ias; $NRF_SDK_DIR$\components\ble\ble_services\ble_ias_c; $NRF_SDK_DIR$\components\ble\ble_services\ble_lbs; $NRF_SDK_DIR$\components\ble\ble_services\ble_lbs_c; $NRF_SDK_DIR$\components\ble\ble_services\ble_lls; $NRF_SDK_DIR$\components\ble\ble_services\ble_nus; $NRF_SDK_DIR$\components\ble\ble_services\ble_nus_c; $NRF_SDK_DIR$\components\ble\ble_services\ble_rscs; $NRF_SDK_DIR$\components\ble\ble_services\ble_rscs_c; $NRF_SDK_DIR$\components\ble\ble_services\ble_tps; $NRF_SDK_DIR$\components\ble\common; $NRF_SDK_DIR$\components\ble\nrf_ble_gatt; $NRF_SDK_DIR$\components\ble\nrf_ble_qwr; $NRF_SDK_DIR$\components\ble\peer_manager; $NRF_SDK_DIR$\components\boards; $NRF_SDK_DIR$\components\drivers_nrf\usbd; $NRF_SDK_DIR$\components\libraries\atomic; $NRF_SDK_DIR$\components\libraries\atomic_fifo; $NRF_SDK_DIR$\components\libraries\atomic_flags; $NRF_SDK_DIR$\components\libraries\balloc; $NRF_SDK_DIR$\components\libraries\bootloader; $NRF_SDK_DIR$\components\libraries\bootloader\ble_dfu; $NRF_SDK_DIR$\components\libraries\bootloader\dfu; $NRF_SDK_DIR$\components\libraries\bsp; $NRF_SDK_DIR$\components\libraries\button; $NRF_SDK_DIR$\components\libraries\cli; $NRF_SDK_DIR$\components\libraries\crc16; $NRF_SDK_DIR$\components\libraries\crc32; $NRF_SDK_DIR$\components\libraries\crypto; $NRF_SDK_DIR$\components\libraries\csense; $NRF_SDK_DIR$\components\libraries\csense_drv; $NRF_SDK_DIR$\components\libraries\delay; $NRF_SDK_DIR$\components\libraries\ecc; $NRF_SDK_DIR$\components\libraries\experimental_log; $NRF_SDK_DIR$\components\libraries\experimental_log\src; $NRF_SDK_DIR$\components\libraries\experimental_memobj; $NRF_SDK_DIR$\components\libraries\experimental_mpu; $NRF_SDK_DIR$\components\libraries\experimental_ringbuf; $NRF_SDK_DIR$\components\libraries\experimental_section_vars; $NRF_SDK_DIR$\components\libraries\experimental_stack_guard; $NRF_SDK_DIR$\components\libraries\experimental_task_manager; $NRF_SDK_DIR$\components\libraries\fds; $NRF_SDK_DIR$\components\libraries\fifo; $NRF_SDK_DIR$\components\libraries\fstorage; $NRF_SDK_DIR$\components\libraries\gfx; $NRF_SDK_DIR$\components\libraries\gpiote; $NRF_SDK_DIR$\components\libraries\hardfault; $NRF_SDK_DIR$\components\libraries\hci; $NRF_SDK_DIR$\components\libraries\led_softblink; $NRF_SDK_DIR$\components\libraries\low_power_pwm; $NRF_SDK_DIR$\components\libraries\mem_manager; $NRF_SDK_DIR$\components\libraries\mutex; $NRF_SDK_DIR$\components\libraries\pwm; $NRF_SDK_DIR$\components\libraries\pwr_mgmt; $NRF_SDK_DIR$\components\libraries\queue; $NRF_SDK_DIR$\components\libraries\scheduler; $NRF_SDK_DIR$\components\libraries\sdcard; $NRF_SDK_DIR$\components\libraries\slip; $NRF_SDK_DIR$\components\libraries\sortlist; $NRF_SDK_DIR$\components\libraries\spi_mngr; $NRF_SDK_DIR$\components\libraries\strerror; $NRF_SDK_DIR$\components\libraries\svc; $NRF_SDK_DIR$\components\libraries\timer; $NRF_SDK_DIR$\components\libraries\twi_mngr; $NRF_SDK_DIR$\components\libraries\twi_sensor; $NRF_SDK_DIR$\components\libraries\uart; $NRF_SDK_DIR$\components\libraries\usbd; $NRF_SDK_DIR$\components\libraries\usbd\class\audio; $NRF_SDK_DIR$\components\libraries\usbd\class\cdc; $NRF_SDK_DIR$\components\libraries\usbd\class\cdc\acm; $NRF_SDK_DIR$\components\libraries\usbd\class\hid; $NRF_SDK_DIR$\components\libraries\usbd\class\hid\generic; $NRF_SDK_DIR$\components\libraries\usbd\class\hid\kbd; $NRF_SDK_DIR$\components\libraries\usbd\class\hid\mouse; $NRF_SDK_DIR$\components\libraries\usbd\class\msc; $NRF_SDK_DIR$\components\libraries\usbd\config; $NRF_SDK_DIR$\components\libraries\util; $NRF_SDK_DIR$\components\nfc\ndef\conn_hand_parser; $NRF_SDK_DIR$\components\nfc\ndef\conn_hand_parser\ac_rec_parser; $NRF_SDK_DIR$\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; $NRF_SDK_DIR$\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; $NRF_SDK_DIR$\components\nfc\ndef\connection_handover\ac_rec; $NRF_SDK_DIR$\components\nfc\ndef\connection_handover\ble_oob_advdata; $NRF_SDK_DIR$\components\nfc\ndef\connection_handover\ble_pair_lib; $NRF_SDK_DIR$\components\nfc\ndef\connection_handover\ble_pair_msg; $NRF_SDK_DIR$\components\nfc\ndef\connection_handover\common; $NRF_SDK_DIR$\components\nfc\ndef\connection_handover\ep_oob_rec; $NRF_SDK_DIR$\components\nfc\ndef\connection_handover\hs_rec; $NRF_SDK_DIR$\components\nfc\ndef\connection_handover\le_oob_rec; $NRF_SDK_DIR$\components\nfc\ndef\generic\message; $NRF_SDK_DIR$\components\nfc\ndef\generic\record; $NRF_SDK_DIR$\components\nfc\ndef\launchapp; $NRF_SDK_DIR$\components\nfc\ndef\parser\message; $NRF_SDK_DIR$\components\nfc\ndef\parser\record; $NRF_SDK_DIR$\components\nfc\ndef\text; $NRF_SDK_DIR$\components\nfc\ndef\uri; $NRF_SDK_DIR$\components\nfc\t2t_lib; $NRF_SDK_DIR$\components\nfc\t2t_lib\hal_t2t; $NRF_SDK_DIR$\components\nfc\t2t_parser; $NRF_SDK_DIR$\components\nfc\t4t_lib; $NRF_SDK_DIR$\components\nfc\t4t_lib\hal_t4t; $NRF_SDK_DIR$\components\nfc\t4t_parser\apdu; $NRF_SDK_DIR$\components\nfc\t4t_parser\cc_file; $NRF_SDK_DIR$\components\nfc\t4t_parser\hl_detection_procedure; $NRF_SDK_DIR$\components\nfc\t4t_parser\tlv; $NRF_SDK_DIR$\components\softdevice\common; $NRF_SDK_DIR$\components\softdevice\s132\headers; $NRF_SDK_DIR$\components\softdevice\s132\headers\nrf52; $NRF_SDK_DIR$\components\toolchain\cmsis\include; $NRF_SDK_DIR$\external\fprintf; $NRF_SDK_DIR$\external\segger_rtt; $NRF_SDK_DIR$\integration\nrfx; $NRF_SDK_DIR$\integration\nrfx\legacy; $NRF_SDK_DIR$\modules\nrfx; $NRF_SDK_DIR$\modules\nrfx\drivers\include; $NRF_SDK_DIR$\modules\nrfx\hal; $NRF_SDK_DIR$\modules\nrfx\mdk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=6; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\ble\ble_link_ctx_manager; ..\..\..\..\..\..\components\ble\ble_racp; ..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\usbd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\components\libraries\csense; ..\..\..\..\..\..\components\libraries\csense_drv; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\ecc; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_mpu; ..\..\..\..\..\..\components\libraries\experimental_ringbuf; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\experimental_stack_guard; ..\..\..\..\..\..\components\libraries\experimental_task_manager; ..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\components\libraries\gfx; ..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sdcard; ..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\components\libraries\spi_mngr; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\twi_mngr; ..\..\..\..\..\..\components\libraries\twi_sensor; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\..\..\components\libraries\usbd\config; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\common; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\components\nfc\ndef\launchapp; ..\..\..\..\..\..\components\nfc\ndef\parser\message; ..\..\..\..\..\..\components\nfc\ndef\parser\record; ..\..\..\..\..\..\components\nfc\ndef\text; ..\..\..\..\..\..\components\nfc\ndef\uri; ..\..\..\..\..\..\components\nfc\t2t_lib; ..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t; ..\..\..\..\..\..\components\nfc\t2t_parser; ..\..\..\..\..\..\components\nfc\t4t_lib; ..\..\..\..\..\..\components\nfc\t4t_lib\hal_t4t; ..\..\..\..\..\..\components\nfc\t4t_parser\apdu; ..\..\..\..\..\..\components\nfc\t4t_parser\cc_file; ..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\..\..\components\nfc\t4t_parser\tlv; ..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: sweat_capacity.hex
  ILINK.IlinkOutputFile: sweat_capacity.out
  ILINK.IlinkIcfFile: sweat_capacity_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../source/: main.c sweat_capacity_sensing.c
    ../config/: sdk_config.h
  group Board Definition
    ../../nRF5_SDK_15.0.0_a53641a/components/boards/: boards.c
  group None
    ../../nRF5_SDK_15.0.0_a53641a/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_BLE
    ../../nRF5_SDK_15.0.0_a53641a/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../nRF5_SDK_15.0.0_a53641a/components/ble/ble_advertising/: ble_advertising.c
    ../../nRF5_SDK_15.0.0_a53641a/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../nRF5_SDK_15.0.0_a53641a/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../nRF5_SDK_15.0.0_a53641a/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../source/ble_services/: ble_nus_sweat.c
  group nRF_DFU
    ../../nRF5_SDK_15.0.0_a53641a/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_Drivers
    ../../nRF5_SDK_15.0.0_a53641a/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_ppi.c nrf_drv_twi.c nrf_drv_uart.c
    ../../nRF5_SDK_15.0.0_a53641a/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_ppi.c nrfx_saadc.c nrfx_twi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c
    ../../nRF5_SDK_15.0.0_a53641a/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/button/: app_button.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/fifo/: app_fifo.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/scheduler/: app_scheduler.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/timer/: app_timer.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/hardfault/: hardfault_implementation.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/atomic_flags/: nrf_atflags.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/atomic/: nrf_atomic.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/balloc/: nrf_balloc.c
    ../../nRF5_SDK_15.0.0_a53641a/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../nRF5_SDK_15.0.0_a53641a/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../nRF5_SDK_15.0.0_a53641a/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_SVC
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
